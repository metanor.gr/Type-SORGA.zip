Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Sorga PROFIL 4.IFC
Time: 2019-11-27T08:13:38
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
