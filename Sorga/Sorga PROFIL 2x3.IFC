Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Sorga PROFIL 2x3.IFC
Time: 2019-11-27T08:13:50
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
